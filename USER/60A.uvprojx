# Keil uVision project 60A.uvprojx, settings and files
target 60A (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 60A
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\CONFIG;..\HARWAVE;..\LIB;..\LIB\CMSIS;..\LIB\CMSIS\Include;..\LIB\CMSIS\RTOS2;..\LIB\CMSIS\RTOS2\Include;..\LIB\CMSIS\RTOS2\RTX;..\LIB\CMSIS\RTOS2\RTX\Include;..\LIB\CMSIS\RTOS2\RTX\Include1;..\LIB\CMSIS\RTOS2\RTX\Library;..\LIB\CMSIS\RTOS2\RTX\Source;..\LIB\CMSIS\RTOS2\RTX\Source\ARM;..\LIB\StdPeriph_Driver\inc;..\RTT;..\SYSTEM;..\TASK;..\USER;.\RTE\_RTX;.\RTE\CMSIS;.\RTE\Compiler;.\RTE\Device\STM32F103RC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x.h system_stm32f10x.h
  group TASK
    ../TASK/: can_receive.c can_send.c correct.c data_acquisition.c fault_dispose.c
  group CONFIG
    ../CONFIG/: can_cfg.h ch_cfg.c ch_cfg.h define.h io_cfg.h module_cfg.c module_cfg.h os_cfg.h sys_def.c sys_def.h
  group HARDWAVE
    ../HARWAVE/: ad5676.c ad5676.h can.c can.h ch.c ch.h common.c common.h crc8_16.c crc8_16.h flash_if.h Init.c Init.h ltc1867.c ltc1867.h module.c module.h spi2.c spi2.h w25q64.c w25q64.h
  group SYSTEM
    ../SYSTEM/: delay.c
  group RTT
    ../RTT/: dbg.h SEGGER_RTT.c SEGGER_RTT_Conf.h SEGGER_RTT_Printf.c
  group CMSIS
    ../LIB/CMSIS/RTOS2/RTX/Library/: cmsis_os1.c
    ../LIB/CMSIS/RTOS2/RTX/Source/ARM/: irq_cm3.s
    ../LIB/CMSIS/RTOS2/RTX/Source/: rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
    ../LIB/CMSIS/Source/: os_systick.c
    ./RTE/CMSIS/: RTX_Config.c RTX_Config.h
  group DEVICE
    ../LIB/StdPeriph_Driver/src/: misc.c stm32f10x_can.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c
    ./RTE/Device/STM32F103RC/: RTE_Device.h startup_stm32f10x_hd.s stm32f10x_conf.h system_stm32f10x.c
